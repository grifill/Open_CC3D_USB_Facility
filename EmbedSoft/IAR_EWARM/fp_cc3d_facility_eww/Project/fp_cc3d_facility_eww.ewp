# IAR project fp_cc3d_facility_eww.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\CMSYS_F1; ..\inc; ..\inc\measure; ..\inc\proto; ..\inc\stm32f103_driver; ..\inc\stm32f103_usb_driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fp_cc3d_facility_eww.bin
  ILINK.IlinkOutputFile: fp_cc3d_facility_eww.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: startup_stm32f10x_md.s
  group CMSYS_F1
    ../CMSYS_F1/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.c core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group inc
    ../inc/: init.h main.h stm32f10x_conf.h stm32f10x_it.h
  group inc/measure
    ../inc/measure/: mems.h mpu6000_driver.h
  group inc/proto
    ../inc/proto/: hw_config.h usb_conf.h usb_desc.h usb_io.h usb_istr.h usb_prop.h usb_pwr.h
  group inc/stm32f103_driver
    ../inc/stm32f103_driver/: misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h system_stm32f10x.h
  group inc/stm32f103_usb_driver
    ../inc/stm32f103_usb_driver/: otgd_fs_cal.h otgd_fs_dev.h otgd_fs_int.h otgd_fs_pcd.h otgd_fs_regs.h usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group src
    ../src/: init.c main.c stm32f10x_it.c
  group src/measure
    ../src/measure/: mems.c mpu6000_driver.c
  group src/proto
    ../src/proto/: hw_config.c usb_desc.c usb_endp.c usb_io.c usb_istr.c usb_prop.c usb_pwr.c
  group src/stm32f103_driver
    ../src/stm32f103_driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group src/stm32f103_usb_driver
    ../src/stm32f103_usb_driver/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
