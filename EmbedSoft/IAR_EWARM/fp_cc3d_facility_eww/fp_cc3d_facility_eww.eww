<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project\fp_cc3d_facility_eww.ewp</path>
  </project>
  <batchBuild/>
</workspace>


